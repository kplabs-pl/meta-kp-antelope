KERNEL_IMAGETYPES += "Image.lzma"

INHERIT += "kernel-lzma"

RDEPENDS:${KERNEL_PACKAGE_NAME}-base = ""