LICENSE = "CLOSED"

inherit u-boot-script

SRC_URI = "file://boot-pins.cmd"

SCRIPTS_PATH = "${WORKDIR}"
