LICENSE = "CLOSED"

IMAGE_INSTALL = "\
    packagegroup-core-boot \
    openssh \
"

IMAGE_LINGUAS = " "

inherit core-image
